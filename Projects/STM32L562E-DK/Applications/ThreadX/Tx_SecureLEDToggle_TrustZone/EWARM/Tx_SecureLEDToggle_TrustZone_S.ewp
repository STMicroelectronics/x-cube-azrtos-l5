# IAR project Tx_SecureLEDToggle_TrustZone_S.ewp, settings and files
configuration Tx_SecureLEDToggle_TrustZone_S (ARM, debug)
  General.OGChipSelectEditMenu: STM32L562QE ST STM32L562QE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L562xx; TX_THREAD_SECURE_STACK_MAXIMUM=16384; TX_THREAD_SECURE_STACK_MINIMUM=256
  ICCARM.CCIncludePath2: ../Secure/Inc; ../Secure_nsclib; ../../../../../../Middlewares/ST/threadx/common/inc/; ../../../../../../Middlewares/ST/threadx/ports/cortex_m33/iar/inc/; ../../../../../../Drivers/BSP/STM32L562E-DK; ../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include; ../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Tx_SecureLEDToggle_TrustZone_S.hex
  ILINK.IlinkOutputFile: Tx_SecureLEDToggle_TrustZone_S.out
  ILINK.IlinkIcfFile: stm32l562xe_flash_s.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l562xx.s
  group Application/User/Secure
    ../Secure/Src/: main.c stm32l5xx_it.c stm32l5xx_hal_msp.c secure_nsc.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32L562E-DK
    ../../../../../../Drivers/BSP/STM32L562E-DK/: stm32l562e_discovery.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal_gtzc.c stm32l5xx_hal.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_cortex.c stm32l5xx_hal_icache.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Secure/Src/: system_stm32l5xx_s.c
  group Middlewares/ThreadX/RTOS/ThreadX/Core/Secure
    ../../../../../../Middlewares/ST/threadx/ports/cortex_m33/iar/src/: tx_thread_secure_stack.c
